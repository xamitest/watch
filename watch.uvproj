# Keil uVision project watch.uvproj, settings and files
target stm32f103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: watch +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1
  c misc: --c99 --inline --asm
  c include: inc
  asm include: inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\UV4Build\watch.sct
  group inc
    ./inc/stm32/: stm32f10x.h
    ./inc/: cortexm3_macro.h
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group stm32f103
    ./: interr.c main.c subs.c watch.c bme280.c
